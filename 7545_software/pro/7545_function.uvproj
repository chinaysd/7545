# Keil uVision project 7545_function.uvproj, settings and files
target 7545 (MCS-51)
  device: SC92F7545 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0x6FF) CLOCK(16000000)
  output: 7545_function +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\user
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group lib
    ../lib/: SC92F754x_C.H
  group bsp
    ../bsp/: bsp_key.c bsp_led.c bsp_timer.c TimeOut.c bsp_uart0.c bsp_uart1.c bsp_pwm.c simulate_uart.c
