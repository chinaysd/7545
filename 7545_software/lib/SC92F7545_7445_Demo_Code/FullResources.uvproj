# Keil uVision project FullResources.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7545 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0x6FF) CLOCK(16000000)
  output: FullResources +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./c/: main.c ADC_Init.c BTM.c EX_Init.c IAP_Init.c IO_Init.c SSI_Init.c Timer_Init.c Uart_Init.c PWM_Init.c Multiplication_Division.c CMP_Init.c
